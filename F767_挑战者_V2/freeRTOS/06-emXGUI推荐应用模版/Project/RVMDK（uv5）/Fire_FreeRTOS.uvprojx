# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER,STM32F767xx,X_GUI_USE_FREERTOS,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F7xx\Include;..\..\Libraries\STM32F7xx_HAL_Driver\Inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\delay;..\..\User\key;..\..\User\led;..\..\User\usart;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\inc;..\..\User\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group USER
    ../../User/: main.c stm32f7xx_it.c FreeRTOSConfig.h
  group BSP
    ../../User/bsp/lcd/: bsp_lcd.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/touch/: bsp_i2c_touch.c gt9xx.c
    ../../User/bsp/flash/: bsp_qspi_flash.c
    ../../User/bsp/sdmmc/: bsp_sdmmc_sd.c
  group Fatfs
    ../../User/FATFS/: diskio.c ff.c ffconf.h sd_diskio.c ff_gen_drv.c
    ../../User/FATFS/option/: cc936.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
  group emxgui/arch
    ../../../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../../../emXGUI_Lib/arch/Inc/: gui_os_port.h gui_drv.h
  group emxgui/resource
    ../../../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../../../../emXGUI_Lib/drv/: gui_startup.c gui_lcd_port.c gui_font_port.c gui_mem_port.c gui_log_port.c gui_touch_port.c gui_input_port.c gui_resource_port.c gui_fs_port.c
  group emxgui/inc
    ../../../../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h
  group emxgui/libs
    ../../../../../emXGUI_Lib/libs/: emXGUI100_MDK_M7.lib x_libc_MDK_M7.lib libjpeg_MDK_M7.lib libpng_MDK_M7.lib
  group base_app
    ../../../../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../../../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
  group app_res
    ../../../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group DOC
    ../../: 必读说明.txt
